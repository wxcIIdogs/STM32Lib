# Keil uVision project stm32f407lib.uvprojx, settings and files
target stm32F4Lib (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407lib +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F407xx,VERSIONV1_0
  c include: ..\user;..\applib\inc;..\hardwareLib\peripheral\inc;..\hardwarelib\cmsis;..\Test
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ../user/: main.c
  group applib
    ../applib/src/: base_com.c
  group hardwarelib
    ../hardwareLib/peripheral/src/: gpioRegister.c rccRegister.c usartRegister.c
  group devices
    ../hardwarelib/device/startup/: startup_stm32f407xx.s
  group test
    ../Test/: main_test.c
  group Optlib
    ../hardwareLib/peripheral/src/: usartOpt.c gpioOpt.c
  group lib
    ../hardwareLib/peripheral/src/: rcc.c gpio.c usart.c
